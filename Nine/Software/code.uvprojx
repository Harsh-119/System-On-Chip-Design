# Keil uVision project code.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: code
  AfterMake: fromelf -cvf .\Objects\code.axf --vhx --32x1 -o code.hex
  AfterMake: fromelf -cvf .\Objects\code.axf -o disasm.txt
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\core;.\device;.\application
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./Application/: main.c
    ./core/: core_cm0.h core_cmFunc.h core_cmInstr.h
    ./device/: cm0dsasm.s EDK_CM0.h edk_driver.c edk_driver.h
software components: CMSIS:CORE 5.6.0
