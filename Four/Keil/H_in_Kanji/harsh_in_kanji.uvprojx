# Keil uVision project harsh_in_kanji.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: code
  AfterMake: fromelf -cvf .\Objects\code.axf --vhx --32x1 -o code.hex
  AfterMake: fromelf -cvf .\Objects\code.axf -o disasm.txt
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: hinkanji.s
software components: CMSIS:CORE 5.6.0
